# Repository uinika/UINIO-Signal-Translator

File README.md:

# UINIO-Signal-Translator 信号电平转换器

[**UINIO-Signal-Translator**](https://gitee.com/uinika/UINIO-Signal-Translator) 是一款基于德州仪器 TSSOP 封装的 [**TXS0108**](https://www.ti.com.cn/product/cn/TXS0108E) 以及 [**TXB0108**](https://www.ti.com.cn/product/cn/TXB0108) 的双向电平信号转换器模组，适用于漏极开路或者推挽输出的应用，支持 `1.8V`、`2.5V`、`3.3V`、`5V` 等常见信号电平之间的相互转换。

## 设计概要

1. 输出使能端 **OE** 需要通过**跳线帽**进行配置；
2. 分别为参考电压 A 与参考电压 B 添加了 LED 指示灯；
3. 增加了 4 个 `1mm` 直径固定螺丝孔，方便与外壳进行固定组装；
4. 转换芯片均采用易于购买的 `TSSOP20` 封装，可以按需使用 **TXS0108** 或者 **TXB0108**；
5. 可以配合串行协议转换器 [UINIO-USB-Serial](https://gitee.com/uinika/UINIO-USB-Serial) 使用，用于调试 `1.8V` 电平信号的 FPGA 芯片外设；

## 输入输出参数

- **TXB0108**：`VCCA` 端电压 `1.2V ~ 3.6V`，`VCCB` 端电压 `1.65V ~ 5.5V`，使能端 `OE` 高电平有效。不能用于 I²C 的开漏输出，只适用于 **UART** 与 **SPI** 总线通信场景。
- **TXS0108**：`VCCA` 端电压 `1.4V ~ 3.6V`，`VCCB` 端电压 `1.65V ~ 5.5V`，使能端 `OE` 高电平有效，同时支持开漏与推挽输出（推挽模式下最大数据速率可以达到 `110Mbps`，开漏模式下则只能达到 `1.2Mbps`），可以同时适用于 **UART**、**I²C**、**SPI** 等总线通信场景。

> **注意**： **TXS0108** 和 **TXB0108** 两款芯片只能完成逻辑电平信号的转换，其驱动能力较小，并不具备带负载能力。

## 参考技术文档

[UinIO.com 电子技术实验室](http://uinio.com/) 为 UINIO-Signal-Translator 开源项目提供了如下一系列技术参考资料：

- [《BOM 交互式物料清单与 PCB 布线在线预览》](http://uinio.com/archives/BOM/UINIO-Signal-Translator.html)

## KiCad design UINIO-Signal-Translator.kicad_pcb

Parts:
C1, C2: 0.1uF; C_0603_1608Metric
D1, D2: LED Blue; LED_0603_1608Metric
J1, J3: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J2, J4, J5, J7: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Vertical
J6: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
R1, R2: 2K; R_0603_1608Metric
R3: 10K; R_0603_1608Metric
U1, U2: TXB0108; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
/OE: J6.2, U1.10 (OE), U2.10 (OE)
/VCCA: C1.2, J1.2, J6.3, R1.1, U1.2 (VCCA), U2.2 (VCCA)
/VCCB: C2.2, J3.2, R2.1, U1.19 (VCCB), U2.19 (VCCB)
GND: C1.1, C2.1, D1.1 (K), D2.1 (K), J1.1, J3.1, R3.1, U1.11 (GND), U2.11 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: J2.1, U1.1 (A1)
unnamed: J2.2, U1.3 (A2)
unnamed: J2.3, U1.4 (A3)
unnamed: J2.4, U1.5 (A4)
unnamed: J2.5, U1.6 (A5)
unnamed: J2.6, U1.7 (A6)
unnamed: J2.7, U1.8 (A7)
unnamed: J2.8, U1.9 (A8)
unnamed: J4.1, U1.20 (B1)
unnamed: J4.2, U1.18 (B2)
unnamed: J4.3, U1.17 (B3)
unnamed: J4.4, U1.16 (B4)
unnamed: J4.5, U1.15 (B5)
unnamed: J4.6, U1.14 (B6)
unnamed: J4.7, U1.13 (B7)
unnamed: J4.8, U1.12 (B8)
unnamed: J5.1, U2.1 (A1)
unnamed: J5.2, U2.3 (A2)
unnamed: J5.3, U2.4 (A3)
unnamed: J5.4, U2.5 (A4)
unnamed: J5.5, U2.6 (A5)
unnamed: J5.6, U2.7 (A6)
unnamed: J5.7, U2.8 (A7)
unnamed: J5.8, U2.9 (A8)
unnamed: J6.1, R3.2
unnamed: J7.1, U2.20 (B1)
unnamed: J7.2, U2.18 (B2)
unnamed: J7.3, U2.17 (B3)
unnamed: J7.4, U2.16 (B4)
unnamed: J7.5, U2.15 (B5)
unnamed: J7.6, U2.14 (B6)
unnamed: J7.7, U2.13 (B7)
unnamed: J7.8, U2.12 (B8)

Notes on the sheet:
同时兼容德州仪器 TSSOP20 封装的 TXB0108 与 TXS0108 两款逻辑电平转换芯片

Board: 2 copper layers, 55.3 x 28.1 mm, 20 parts (0 on the bottom side), 39 nets.

Other parts of the board:
HOLE**: Hole-1mm
HOLE**#2, HOLE**#3, HOLE**#4: Hole-1mm

## Commit log

2023-12-29 Initialization UINIO-Level-Translator project.
2024-01-08 Initialization project.
2024-01-08 Attach more datasheets.
2024-01-09 Release UINIO-Signal-Translator version 1.0.0.
2024-01-09 Update README.md.
2024-03-12 Release UINIO-Signal-Translator version 2.0.0.
